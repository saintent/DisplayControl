# IAR project LocalTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F0XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; 01.Inc\; 01.Inc\api; 01.Inc\driver; Libraries\CMSIS\Device\ST\STM32F0xx\Include; Libraries\STM32F0xx_StdPeriph_Driver\inc; Libraries\STM32F0xx_CPAL_Driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LocalTest.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    02.Src/: system_stm32f0xx.c
  group Lib
    STM32F0xx_StdPeriph_Lib_V1.0.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Src
    02.Src/: app.c main.c stm32f0xx_it.c
  group Src/api
    02.Src/api/: at_command.c bt.c led.c
  group Src/driver
    02.Src/driver/: timer.c uart.c
  group StartUp
    ./: startup_stm32f0xx.s
